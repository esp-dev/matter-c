#include <stdio.h>
#include <stdlib.h>
#include <string.h>
#include "codec/matter_tlv_writer.h"
#include "codec/matter_tlv_internal.h"

#define CHECK(condition) do { if (!(condition)) { \
    fprintf(stderr, "%s:%d %s: %s\n", __FILE__, __LINE__, __func__, #condition); \
    return false; } } while (0)

#include "test_tlv_reference.h"
typedef Tlv_Reference_Token Token;
#define SIMPLE(t) {{.type = MATTER_TLV_##t},0}
#define SIGNED(v,w) {{.type = MATTER_TLV_SIGNED,.signed_value = (v)},w}
#define UNSIGNED(v,w) {{.type = MATTER_TLV_UNSIGNED,.unsigned_value = (v)},w}
#define TEXT(s) {{.type = MATTER_TLV_UTF8,.data = (const uint8_t*)(s),.size = sizeof(s)-1},1}
#define CONTEXT(v,n) {{.type = MATTER_TLV_SIGNED,.tag = {.control = 1,.number = n},.signed_value = (v)},1}
#define FLOAT(t,v) {{.type = MATTER_TLV_##t,.unsigned_value = (v)},0}
#define DOCUMENT(bytes,tokens) CHECK(vector(bytes,sizeof(bytes)-1,tokens,sizeof(tokens)/sizeof(tokens[0])))

/* Expected bytes generated by independent Python integer/struct encoding.
 * Semantic input tokens are constructed without decoding.
 * Compare bytes first, then use reader only as supplementary validation.
 * Every capacity below the required size exercises per-token atomic failure.
 */
static bool vector(const char* expected, size_t size, const Token* tokens, size_t count) {
    CHECK(size < 96);
    for (size_t capacity = 0; capacity <= size; ++capacity) {
        uint8_t output[96], before[96]; /* Small host-only test snapshots. */
        memset(output,0xa5,sizeof(output));
        Matter_Tlv_Writer_T writer, saved;
        Matter_Tlv_Writer_T measure;
        CHECK(matter_tlv_measure_init(&measure,capacity,16)==MATTER_TLV_OK);
        CHECK(matter_tlv_writer_init(&writer,output,capacity,16) == MATTER_TLV_OK);
        bool failed = false;
        for (size_t i = 0; i < count; ++i) {
            memcpy(before,output,sizeof(output)); memcpy(&saved,&writer,sizeof(writer));
            Matter_Tlv_Result_T result = matter_tlv_write(&writer,&tokens[i].element,tokens[i].width);
            Matter_Tlv_Writer_T measured_before=measure;
            CHECK(matter_tlv_write(&measure,&tokens[i].element,tokens[i].width)==result);
            CHECK(measure.size==writer.size && measure.depth==writer.depth && measure.root_seen==writer.root_seen);
            if(result!=MATTER_TLV_OK) CHECK(!memcmp(&measure,&measured_before,sizeof(measure)));
            if (result == MATTER_TLV_NO_SPACE) {
                CHECK(memcmp(output,before,sizeof(output)) == 0);
                CHECK(memcmp(&writer,&saved,sizeof(writer)) == 0);
                CHECK(matter_tlv_write(&writer,&tokens[i].element,tokens[i].width) == result);
                failed = true; break;
            }
            CHECK(result == MATTER_TLV_OK);
            CHECK(writer.size <= capacity && memcmp(output,expected,writer.size) == 0);
            size_t written = SIZE_MAX;
            CHECK(matter_tlv_writer_finish(&writer,&written) ==
                (i + 1 == count ? MATTER_TLV_OK : MATTER_TLV_TRUNCATED));
            CHECK(written == (i + 1 == count ? size : SIZE_MAX));
            size_t measured=SIZE_MAX;
            CHECK(matter_tlv_writer_finish(&measure,&measured)==(i+1==count?MATTER_TLV_OK:MATTER_TLV_TRUNCATED));
            CHECK(measured==written);
        }
        CHECK(failed == (capacity < size));
        for (size_t i = writer.size; i < sizeof(output); ++i) CHECK(output[i] == 0xa5);
        if (!failed) {
            size_t written = 0;
            CHECK(matter_tlv_writer_finish(&writer,&written) == MATTER_TLV_OK && written == size);
            CHECK(memcmp(output,expected,size) == 0);
            Matter_Tlv_Reader_T reader;
            Matter_Tlv_Element_T element;
            CHECK(matter_tlv_init(&reader,output,size,16) == MATTER_TLV_OK);
            for (size_t i = 0; i < count; ++i) {
                CHECK(matter_tlv_next(&reader,&element) == MATTER_TLV_OK);
                CHECK(element.type == tokens[i].element.type);
            }
            CHECK(matter_tlv_next(&reader,&element) == MATTER_TLV_DONE);
        }
    }
    return true;
}

static bool test_reference_vectors(void) {
    for(size_t i=0;i<sizeof(tlv_reference)/sizeof(tlv_reference[0]);++i) {
        const Tlv_Reference_Case* v=&tlv_reference[i];
        CHECK(vector((const char*)v->data,v->size,v->tokens,v->count));
    }
    return true;
}

static bool test_tag_boundaries(void) {
    /* Additional A.8 boundary cases, including implicit profiles. */
    static const uint32_t numbers[] = {0,255,65535,65536,65535,UINT32_MAX,65535,UINT32_MAX};
    static const char* bytes[] = {"\x04\x2a","\x24\xff\x2a","\x44\xff\xff\x2a","\x64\0\0\1\0\x2a",
        "\x84\xff\xff\x2a","\xa4\xff\xff\xff\xff\x2a","\xc4\0\0\0\0\xff\xff\x2a",
        "\xe4\0\0\0\0\xff\xff\xff\xff\x2a"};
    static const size_t lengths[] = {2,3,4,6,4,6,8,10};
    for (uint8_t c=0;c<8;++c) {
        Token tokens[] = {SIMPLE(LIST),UNSIGNED(42,1),SIMPLE(END)};
        tokens[1].element.tag = (Matter_Tlv_Tag_T){.control=c,.number=numbers[c]};
        char expected[12] = {0x17};
        memcpy(expected+1,bytes[c],lengths[c]); expected[1+lengths[c]]=0x18;
        CHECK(vector(expected,lengths[c]+2,tokens,3));
    }
    return true;
}

/* Snapshot the entire small host fixture, including bytes outside capacity. */
static bool rejected(Matter_Tlv_Writer_T* writer, const Matter_Tlv_Element_T* element,
    uint8_t width, Matter_Tlv_Result_T expected, uint8_t* output, size_t size) {
    uint8_t before[96]; Matter_Tlv_Writer_T saved;
    CHECK(size <= sizeof(before));
    memcpy(before,output,size); memcpy(&saved,writer,sizeof(saved));
    Matter_Tlv_Writer_T measure=*writer, measured_before;
    measure.data=NULL; measured_before=measure;
    CHECK(matter_tlv_write(&measure,element,width)==expected);
    CHECK(!memcmp(&measure,&measured_before,sizeof(measure)));
    CHECK(matter_tlv_write(writer,element,width) == expected);
    CHECK(memcmp(before,output,size) == 0 && memcmp(&saved,writer,sizeof(saved)) == 0);
    return true;
}

static bool test_integer_boundaries(void) {
    static const uint8_t widths[] = {1,2,4,8};
    uint8_t output[16]; Matter_Tlv_Writer_T writer; Matter_Tlv_Reader_T reader; Matter_Tlv_Element_T read;
    for (unsigned i=0;i<4;++i) {
        uint8_t width=widths[i];
        uint64_t umax = width==8 ? UINT64_MAX : (UINT64_C(1)<<(width*8))-1;
        int64_t smax = (int64_t)(umax>>1), smin = -smax-1;
        for (unsigned type=0;type<2;++type) for (unsigned boundary=0;boundary<2;++boundary) {
            Matter_Tlv_Element_T value = {.type=type ? MATTER_TLV_UNSIGNED : MATTER_TLV_SIGNED,
                .unsigned_value=boundary ? umax : 0,.signed_value=boundary ? smax : smin};
            CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),1)==MATTER_TLV_OK);
            CHECK(matter_tlv_write(&writer,&value,width)==MATTER_TLV_OK && writer.size==(size_t)width+1);
            CHECK(output[0]==i+(type ? 4 : 0));
            for (unsigned j=1;j<=width;++j) {
                uint8_t expected = type ? (boundary ? 255 : 0) :
                    (boundary ? (j==width ? 127 : 255) : (j==width ? 128 : 0));
                CHECK(output[j]==expected);
            }
            CHECK(matter_tlv_init(&reader,output,writer.size,1)==MATTER_TLV_OK);
            CHECK(matter_tlv_next(&reader,&read)==MATTER_TLV_OK);
            CHECK(type ? read.unsigned_value==value.unsigned_value : read.signed_value==value.signed_value);
            CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),1)==MATTER_TLV_OK);
            CHECK(matter_tlv_write(&writer,&value,0)==MATTER_TLV_OK);
            CHECK(writer.size==(type && !boundary ? 2 : (size_t)width+1));
        }
        if (width==8) continue;
        Matter_Tlv_Element_T bad = {.type=MATTER_TLV_UNSIGNED,.unsigned_value=umax+1};
        CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),1)==MATTER_TLV_OK);
        CHECK(rejected(&writer,&bad,width,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
        bad.type=MATTER_TLV_SIGNED; bad.signed_value=smax+1;
        CHECK(rejected(&writer,&bad,width,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
        CHECK(matter_tlv_write(&writer,&bad,0)==MATTER_TLV_OK && output[0]==i+1);
        CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),1)==MATTER_TLV_OK);
        bad.signed_value=smin-1;
        CHECK(rejected(&writer,&bad,width,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
        CHECK(matter_tlv_write(&writer,&bad,0)==MATTER_TLV_OK && output[0]==i+1);
    }
    return true;
}

static bool lengths(uint8_t* output, const uint8_t* source) {
    static const size_t sizes[] = {0,1,255,256,65535,65536};
    static const uint8_t codes[] = {0,0,0,1,1,2};
    Matter_Tlv_Writer_T writer; Matter_Tlv_Reader_T reader; Matter_Tlv_Element_T read;
    for (size_t i=0;i<6;++i) for (unsigned type=0;type<2;++type) {
        Matter_Tlv_Element_T value={.type=type ? MATTER_TLV_UTF8 : MATTER_TLV_BYTES,.data=source,.size=sizes[i]};
        CHECK(matter_tlv_writer_init(&writer,output,65554,1)==MATTER_TLV_OK);
        CHECK(matter_tlv_write(&writer,&value,0)==MATTER_TLV_OK);
        CHECK(output[0]==(type ? 12 : 16)+codes[i]);
        size_t width=(size_t)1<<codes[i];
        CHECK(writer.size==1+width+sizes[i]);
        for (size_t j=0;j<width;++j) CHECK(output[1+j]==(uint8_t)(sizes[i]>>(j*8)));
        CHECK(memcmp(output+1+width,source,sizes[i])==0);
        CHECK(matter_tlv_init(&reader,output,writer.size,1)==MATTER_TLV_OK);
        CHECK(matter_tlv_next(&reader,&read)==MATTER_TLV_OK && read.size==sizes[i]);
        CHECK(memcmp(read.data,source,sizes[i])==0);
    }
    return true;
}

static bool test_lengths_and_overflow(void) {
    uint8_t* source=malloc(65536); uint8_t* output=malloc(65554);
    if (!source || !output) { free(source); free(output); return false; }
    memset(source,'a',65536);
    bool passed=lengths(output,source);
    free(source); free(output);
    CHECK(passed);
    for (uint8_t width=1; width<=8; width*=2) {
        char expected[11]={0}; expected[0]=(char)(16+(width==1 ? 0 : width==2 ? 1 : width==4 ? 2 : 3));
        expected[1]=2; expected[2+width]=(char)0xff;
        Token token={{.type=MATTER_TLV_BYTES,.data=(const uint8_t*)"\0\xff",.size=2},width};
        CHECK(vector(expected,3+width,&token,1));
    }
    uint8_t small[32]={0}; Matter_Tlv_Writer_T writer;
    CHECK(matter_tlv_writer_init(&writer,small,sizeof(small),1)==MATTER_TLV_OK);
    /* Capacity rejection precedes payload access, including UTF-8 validation. */
    Matter_Tlv_Element_T huge={.type=MATTER_TLV_UTF8,.data=(const uint8_t*)"x",.size=SIZE_MAX};
    CHECK(rejected(&writer,&huge,0,MATTER_TLV_NO_SPACE,small,sizeof(small)));
    huge.type=MATTER_TLV_BYTES; huge.size=256;
    CHECK(rejected(&writer,&huge,1,MATTER_TLV_INVALID_ARGUMENT,small,sizeof(small)));
    huge.data=NULL;
    CHECK(rejected(&writer,&huge,0,MATTER_TLV_INVALID_ARGUMENT,small,sizeof(small)));
    return true;
}

static bool test_errors_and_utf8(void) {
    uint8_t output[48]={0}; Matter_Tlv_Writer_T writer, saved;
    Matter_Tlv_Element_T value={.type=MATTER_TLV_NULL}; size_t size=99;
    CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),2)==MATTER_TLV_OK);
    memcpy(&saved,&writer,sizeof(saved));
    CHECK(matter_tlv_writer_init(&writer,NULL,1,1)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),0)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_writer_init(&writer,output,sizeof(output),17)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(memcmp(&saved,&writer,sizeof(saved))==0);
    CHECK(matter_tlv_writer_init(NULL,NULL,0,1)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_write(NULL,&value,0)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_write(&writer,NULL,0)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_writer_finish(NULL,&size)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_writer_finish(&writer,NULL)==MATTER_TLV_INVALID_ARGUMENT);
    CHECK(matter_tlv_writer_finish(&writer,&size)==MATTER_TLV_TRUNCATED && size==99);
    CHECK(rejected(&writer,&value,1,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
    CHECK(rejected(&writer,&value,3,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
    value.type=(Matter_Tlv_Type_T)99;
    CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
    value.type=MATTER_TLV_BOOL; value.unsigned_value=2;
    CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
    value.type=MATTER_TLV_FLOAT32; value.unsigned_value=UINT64_MAX;
    CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
    static const Matter_Tlv_Tag_T tags[]={
        {.control=8},{.control=0,.number=1},{.control=1,.number=256},
        {.control=2,.number=65536},{.control=3,.number=65535},
        {.control=4,.number=65536},{.control=5,.number=65535},
        {.control=6,.number=65536},{.control=7,.number=65535},
        {.control=0,.vendor=1},{.control=2,.profile=1}
    };
    value.type=MATTER_TLV_NULL;
    for (size_t i=0;i<sizeof(tags)/sizeof(tags[0]);++i) {
        value.tag=tags[i];
        CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ARGUMENT,output,sizeof(output)));
    }
    value.tag=(Matter_Tlv_Tag_T){.control=1};
    CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ENCODING,output,sizeof(output)));
    value=(Matter_Tlv_Element_T){.type=MATTER_TLV_END};
    CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ENCODING,output,sizeof(output)));
    static const struct { const char* text; size_t size; } invalid[]={
        {"\x80",1},{"\xc0\xaf",2},{"\xc2\x20",2},{"\xe2\x82",2},
        {"\xe0\x80\x80",3},{"\xed\xa0\x80",3},{"\xf0\x80\x80\x80",4},
        {"\xf4\x90\x80\x80",4},{"\xf5",1}
    };
    for (size_t i=0;i<sizeof(invalid)/sizeof(invalid[0]);++i) {
        value=(Matter_Tlv_Element_T){.type=MATTER_TLV_UTF8,.data=(const uint8_t*)invalid[i].text,.size=invalid[i].size};
        CHECK(rejected(&writer,&value,0,MATTER_TLV_INVALID_ENCODING,output,sizeof(output)));
    }
    static const Token utf8[]={TEXT("\0\xc2\x80\xe0\xa0\x80\xed\x9f\xbf\xf0\x90\x80\x80\xf4\x8f\xbf\xbf")};
    DOCUMENT("\x0c\x11\0\xc2\x80\xe0\xa0\x80\xed\x9f\xbf\xf0\x90\x80\x80\xf4\x8f\xbf\xbf",utf8);
    Token empty={{.type=MATTER_TLV_UTF8},0};
    CHECK(vector("\x0c\0",2,&empty,1));
    empty.element.type=MATTER_TLV_BYTES;
    CHECK(vector("\x10\0",2,&empty,1));
    CHECK(matter_tlv_writer_init(&writer,NULL,0,1)==MATTER_TLV_OK);
    value=(Matter_Tlv_Element_T){.type=MATTER_TLV_NULL};
    CHECK(matter_tlv_write(&writer,&value,0)==MATTER_TLV_NO_SPACE);
    CHECK(matter_tlv_writer_init(&writer,output,2,1)==MATTER_TLV_OK);
    value=(Matter_Tlv_Element_T){.type=MATTER_TLV_UNSIGNED,.unsigned_value=256};
    CHECK(rejected(&writer,&value,0,MATTER_TLV_NO_SPACE,output,sizeof(output)));
    value.unsigned_value=42;
    CHECK(matter_tlv_write(&writer,&value,0)==MATTER_TLV_OK);
    CHECK(matter_tlv_writer_finish(&writer,&size)==MATTER_TLV_OK && size==2);
    CHECK(output[0]==4 && output[1]==42); /* corrected retry after NO_SPACE */
    return true;
}

static bool test_container_state_and_two_writers(void) {
    uint8_t a[48]={0}, b[8]={0}; Matter_Tlv_Writer_T first,second;
    Matter_Tlv_Element_T open={.type=MATTER_TLV_ARRAY}, end={.type=MATTER_TLV_END}, value={.type=MATTER_TLV_NULL};
    CHECK(matter_tlv_writer_init(&first,a,sizeof(a),16)==MATTER_TLV_OK);
    CHECK(matter_tlv_writer_init(&second,b,sizeof(b),1)==MATTER_TLV_OK);
    CHECK(matter_tlv_write(&second,&open,0)==MATTER_TLV_OK);
    for (unsigned i=0;i<16;++i) CHECK(matter_tlv_write(&first,&open,0)==MATTER_TLV_OK);
    CHECK(rejected(&first,&open,0,MATTER_TLV_DEPTH_LIMIT,a,sizeof(a)));
    CHECK(rejected(&second,&open,0,MATTER_TLV_DEPTH_LIMIT,b,sizeof(b)));
    value.tag.control=1;
    CHECK(rejected(&first,&value,0,MATTER_TLV_INVALID_ENCODING,a,sizeof(a)));
    end.tag.control=1;
    CHECK(rejected(&first,&end,0,MATTER_TLV_INVALID_ENCODING,a,sizeof(a)));
    end.tag.control=0;
    for (unsigned i=0;i<16;++i) CHECK(matter_tlv_write(&first,&end,0)==MATTER_TLV_OK);
    size_t size=0;
    CHECK(matter_tlv_writer_finish(&first,&size)==MATTER_TLV_OK && size==32);
    CHECK(second.size==1 && second.depth==1 && b[0]==0x16);
    value.tag.control=0;
    CHECK(rejected(&first,&value,0,MATTER_TLV_INVALID_ENCODING,a,sizeof(a)));
    CHECK(rejected(&first,&end,0,MATTER_TLV_INVALID_ENCODING,a,sizeof(a)));
    CHECK(matter_tlv_write(&second,&value,0)==MATTER_TLV_OK);
    CHECK(matter_tlv_write(&second,&end,0)==MATTER_TLV_OK);
    CHECK(matter_tlv_writer_finish(&second,&size)==MATTER_TLV_OK && size==3);
    CHECK(memcmp(b,"\x16\x14\x18",3)==0);
    CHECK(matter_tlv_writer_init(&first,a,sizeof(a),1)==MATTER_TLV_OK);
    open.type=MATTER_TLV_STRUCTURE;
    CHECK(matter_tlv_write(&first,&open,0)==MATTER_TLV_OK);
    CHECK(rejected(&first,&value,0,MATTER_TLV_INVALID_ENCODING,a,sizeof(a)));
    value.tag.control=1;
    CHECK(matter_tlv_write(&first,&value,0)==MATTER_TLV_OK); /* corrected retry */
    CHECK(matter_tlv_write(&first,&end,0)==MATTER_TLV_OK);
    CHECK(memcmp(a,"\x15\x34\0\x18",4)==0);
    return true;
}

int main(void) {
    const struct { const char* name; bool (*run)(void); } tests[]={
        {"synthetic matrix / all short capacities",test_reference_vectors},
        {"all tag boundaries / short capacities",test_tag_boundaries},
        {"integer widths, limits and automatic sizing",test_integer_boundaries},
        {"string length transitions and overflow",test_lengths_and_overflow},
        {"atomic errors, arguments and UTF-8",test_errors_and_utf8},
        {"container state, depth, retry and two writers",test_container_state_and_two_writers},
    };
    unsigned failures=0;
    for (size_t i=0;i<sizeof(tests)/sizeof(tests[0]);++i) {
        bool passed=tests[i].run();
        printf("%s tlv writer: %s\n",passed ? "PASS" : "FAIL",tests[i].name);
        if (!passed) ++failures;
    }
    return failures ? EXIT_FAILURE : EXIT_SUCCESS;
}
